/*
 * Copyright (c) 2020-2023 Cryptography Research, Inc. (CRI).
 * A license or authorization from CRI is needed to use this file.
 */

#include <string.h>
#include <init.h>
#include <drivers/cmrt/hc.h>
#include <drivers/cmrt/eac.h>
#include <drivers/cmrt/sic.h>
#include "hc_kat.h"
#include "../hc_int.h"

#include <logging/log.h>
LOG_MODULE_DECLARE(cmrt, CONFIG_CMRT_LOG_LEVEL);

#ifdef __GNUC__
/* Many variables are only used on certain configurations, and will return
 * an error.  We do not want to force linkage to them, or, make them globally
 * visible either.
 */
#pragma GCC diagnostic ignored "-Wunused-const-variable"
#endif


#define INIT_SHA_HC_KAT_T(algo, input, output) \
	{				       \
		algo,                          \
		NULL,                          \
		0,                             \
		input,                         \
		sizeof(input),                 \
		output,                        \
		sizeof(output)                 \
	}
#define INIT_HMAC_HC_KAT_T(algo, key, input, output) \
	{					     \
		algo,				     \
		key,				     \
		sizeof(key),			     \
		input,				     \
		sizeof(input),			     \
		output,			     \
		sizeof(output)			     \
	}

/* Hash Core Vectors */
static const uint8_t key0[] = {
	0x2d, 0xc4, 0x77, 0xac, 0x10, 0xd6, 0xc0, 0x7b,
	0x3f, 0xe0, 0x08, 0xf6, 0x36, 0x03, 0x77, 0x33
};

static const uint8_t input0[] = {
	0x37, 0x40, 0xd8, 0xa2, 0xfd, 0x15, 0xbb, 0xe6,
	0xda, 0x49, 0xed, 0x89, 0x03, 0xc6, 0x28, 0xba,
	0x57, 0x8c, 0x86, 0x70, 0x0b, 0xf9, 0x62, 0x8f,
	0xc8, 0xd3, 0x8f, 0x97, 0x48, 0xf0, 0xcd, 0xeb
};

/* python: output3_sha256 = hashlib.sha256(input0) */
static const uint8_t output3_sha256[] = {
	0x78, 0xcd, 0x63, 0x93, 0xa7, 0x33, 0xf8, 0x18,
	0x9a, 0xda, 0xeb, 0x9e, 0xcc, 0x33, 0x0e, 0x23,
	0x25, 0x48, 0xe2, 0x68, 0xb6, 0xd5, 0x20, 0xec,
	0xe7, 0x0a, 0xbd, 0x88, 0x6a, 0x6a, 0x27, 0xc3
};

/* python: output7_sha512 = hashlib.sha512(input0) */
static const uint8_t output7_sha512[] = {
	0x09, 0x50, 0xce, 0x89, 0xe3, 0xef, 0x34, 0x3e,
	0x86, 0x61, 0x70, 0x5c, 0x19, 0xd0, 0xfb, 0x08,
	0x9a, 0x38, 0x93, 0x0d, 0x93, 0x1d, 0x65, 0xf3,
	0xad, 0x70, 0x3d, 0x01, 0x50, 0xe8, 0xfa, 0x1f,
	0x0c, 0xc0, 0x8d, 0x11, 0x3a, 0xd1, 0x29, 0xa4,
	0x55, 0x91, 0x09, 0x75, 0xac, 0x83, 0x30, 0x3c,
	0xdf, 0xe4, 0x1d, 0xc7, 0xdb, 0x83, 0x50, 0x3b,
	0x33, 0x4a, 0x76, 0xce, 0x18, 0x8a, 0x38, 0xc6
};

/* python: output2_hmac_sha256 = hmac.new(key0, input0, hashlib.sha256) */
static const uint8_t output2_hmac_sha256[] = {
	0x19, 0xdd, 0xf2, 0xbd, 0x8e, 0x93, 0xd5, 0x81,
	0xe4, 0x90, 0xc1, 0x86, 0xf0, 0x18, 0x76, 0xf0,
	0xd9, 0x70, 0xc1, 0x4a, 0xcd, 0x62, 0x40, 0x9b,
	0x0e, 0x16, 0xfd, 0x7f, 0x94, 0x98, 0xd5, 0xbb
};

/* python: output0_hmac_sha224 = hmac.new(key0, input0, hashlib.sha224) */
static const uint8_t output0_hmac_sha224[] = {
	0xd6, 0xcc, 0x1b, 0xa9, 0x50, 0xd5, 0x48, 0xd2,
	0x8a, 0x0a, 0xbe, 0x22, 0x06, 0x00, 0xb6, 0xf2,
	0xf4, 0x98, 0xef, 0x32, 0xc0, 0x9c, 0x5f, 0xe0,
	0x29, 0x88, 0x28, 0xd7
};

/* python: output1_sha224 = hashlib.sha224(input0) */
static const uint8_t output1_sha224[] = {
	0x70, 0xc2, 0xf2, 0x5b, 0x0d, 0x96, 0xbc, 0x6c,
	0xb5, 0xc7, 0x60, 0x05, 0x46, 0xce, 0xc6, 0x55,
	0x88, 0x8e, 0x80, 0x7b, 0xc2, 0xde, 0x29, 0xee,
	0x90, 0x82, 0x6c, 0x41
};

/* python: output4_hmac_sha384 = hmac.new(key0, input0, hashlib.sha384) */
static const uint8_t output4_hmac_sha384[] = {
	0x0e, 0xe8, 0x21, 0xbd, 0xb9, 0xde, 0xd6, 0x8d,
	0x84, 0x93, 0x3a, 0x4b, 0x91, 0xce, 0x59, 0x75,
	0x98, 0xed, 0xde, 0xe4, 0x5b, 0xad, 0x44, 0x79,
	0x9f, 0x54, 0x0e, 0x42, 0xba, 0x54, 0x60, 0x7d,
	0x93, 0xdf, 0x5f, 0xe9, 0xaa, 0x6f, 0x85, 0x54,
	0x42, 0x62, 0x14, 0x8a, 0x33, 0xaf, 0x04, 0x5d
};

/* python: output5_sha384 = hashlib.sha384(input0) */
static const uint8_t output5_sha384[] = {
	0x9c, 0x71, 0x28, 0xa6, 0xa9, 0x06, 0xaa, 0xee,
	0x5f, 0x08, 0x1e, 0xb3, 0xd0, 0x3c, 0xbd, 0x37,
	0xa3, 0x09, 0x74, 0xa3, 0xf3, 0x5c, 0xea, 0x3d,
	0x5c, 0xca, 0x67, 0xe3, 0x46, 0xcb, 0xea, 0x43,
	0xa6, 0xbf, 0x9c, 0xe4, 0xf7, 0x46, 0xbb, 0x72,
	0x00, 0xdb, 0x24, 0xd1, 0x4c, 0xe6, 0xdf, 0xe4
};

/* python: output6_hmac_sha512 = hmac.new(key0, input0, hashlib.sha512) */
static const uint8_t output6_hmac_sha512[] = {
	0xf5, 0x2b, 0x43, 0x7b, 0xc3, 0x55, 0xd8, 0x54,
	0x70, 0xb6, 0xc4, 0xd7, 0x05, 0xeb, 0x8b, 0x27,
	0xc4, 0x8d, 0x0b, 0x78, 0x7e, 0x9d, 0xe8, 0x8e,
	0xd7, 0x53, 0x3d, 0x51, 0xa4, 0x5e, 0xfd, 0x66,
	0x4d, 0x96, 0xe3, 0x1b, 0x5b, 0xd2, 0xa0, 0xca,
	0x6d, 0x3e, 0x5a, 0xe9, 0xc2, 0x8a, 0x2f, 0x87,
	0xfb, 0xbb, 0x85, 0x9e, 0x5c, 0x8f, 0x0b, 0x72,
	0x90, 0x42, 0xdc, 0x0d, 0x8a, 0x63, 0xe3, 0x2a
};

/* python: output8_sha512_224 = SHA512.new(input0, truncate="224") */
static const uint8_t output8_sha512_224[] = {
	0xe9, 0x42, 0x64, 0x9e, 0xa4, 0xc5, 0x7c, 0xd0,
	0x2d, 0x64, 0xe3, 0x9c, 0x56, 0x61, 0x18, 0xff,
	0x7e, 0x9f, 0x2d, 0x25, 0x96, 0x77, 0xd9, 0xdb,
	0x62, 0x4b, 0xec, 0x4f
};

/* python: output9_sha512_256 = SHA512.new(input0, truncate="256") */
static const uint8_t output9_sha512_256[] = {
	0xb0, 0xe6, 0x19, 0x99, 0x75, 0xbd, 0xb0, 0xdd,
	0x8e, 0x79, 0xe0, 0x4b, 0x43, 0xd4, 0x3a, 0xd0,
	0xf9, 0xdf, 0x83, 0x44, 0x38, 0x41, 0x75, 0x51,
	0x5a, 0xae, 0x17, 0xd9, 0x12, 0x25, 0xbf, 0x31
};

/* Hash Core Vector 1 */
static const uint8_t input1[] = {
	0x48, 0xc3, 0x85, 0xa9, 0x6d, 0xb4, 0x59, 0x95,
	0x8a, 0x03, 0xb1, 0x49, 0x95, 0x2e, 0xed, 0xe8,
	0x9e, 0xcf, 0x38, 0xdd, 0x7d, 0x5f, 0xb8, 0xde,
	0xbb, 0xe9, 0xb8, 0xdc, 0x5e, 0xef, 0x7b, 0x65
};

/* python: output1_sha3_sha256 = hashlib.sha3_256(input0) */
static const uint8_t output1_sha3_sha256[] = {
	0x9f, 0x2f, 0x43, 0x45, 0x81, 0x3a, 0x66, 0x1a,
	0x33, 0xc2, 0x6d, 0xdc, 0x90, 0x2f, 0x4a, 0xdf,
	0xf9, 0xd4, 0xfb, 0xfe, 0xba, 0x80, 0xf9, 0xea,
	0x2f, 0xd0, 0x42, 0x97, 0x08, 0xe1, 0x9d, 0xc2
};

/* python: output2_hmac_sha3_sha256 = hmac.new(key0, input0, hashlib.sha3_256) */
static const uint8_t output2_hmac_sha3_sha256[] = {
	0x8b, 0x37, 0xbc, 0xeb, 0x07, 0x89, 0x42, 0xe9,
	0x73, 0x62, 0xc1, 0x29, 0x6e, 0x1a, 0x07, 0x31,
	0xce, 0xf6, 0x6f, 0xdf, 0x57, 0x46, 0xa5, 0x60,
	0x0f, 0xfa, 0xff, 0x52, 0x92, 0x2f, 0xed, 0xda
};

static const uint8_t output4_sha256[] = {
	0x22, 0x22, 0xb6, 0xe3, 0x10, 0x31, 0x41, 0x66,
	0x44, 0x66, 0xd1, 0x87, 0x4f, 0xf1, 0x49, 0x82,
	0x71, 0x46, 0x40, 0x04, 0xfe, 0xc4, 0x74, 0x38,
	0xb9, 0xd7, 0x1e, 0x43, 0x76, 0x4d, 0x79, 0x40
};

static const uint8_t output5_sha512[] = {
	0x00, 0x43, 0x06, 0x59, 0x55, 0x35, 0x6b, 0xe5,
	0xc6, 0x7b, 0x63, 0x0e, 0x7b, 0xa8, 0x87, 0x0f,
	0xe4, 0x92, 0x06, 0xf2, 0xd8, 0x19, 0x32, 0xa2,
	0x89, 0x89, 0x11, 0x98, 0x20, 0x66, 0x64, 0xa5,
	0xeb, 0x12, 0xde, 0x17, 0xa9, 0x80, 0x23, 0x23,
	0x00, 0x35, 0xcf, 0x07, 0xf1, 0xfc, 0x34, 0x39,
	0xae, 0xa2, 0xf9, 0xa1, 0x53, 0xbf, 0xaf, 0xb2,
	0x4f, 0x94, 0xa4, 0xb3, 0x88, 0x9b, 0x64, 0xdb
};

#if defined(CONFIG_CMRT_FIPS_140_MODE) && !defined(CONFIG_CMRT_ASIL_B_MODE)
/* Populate HC KAT vectors array. */
const hc_kat_t s2hc_kat_vectors[] = {
	INIT_SHA_HC_KAT_T(CMRT_HASH_SHA256, input0, output3_sha256),
#ifdef CONFIG_SUPERVISOR_MODE
	INIT_HMAC_HC_KAT_T(CMRT_HASH_SHA256, key0, input0, output2_hmac_sha256),
#endif
#if defined(CONFIG_SUPERVISOR_MODE) || defined(CONFIG_CMRT_FBOOT_HAS_ECDSA_P521)
	INIT_SHA_HC_KAT_T(CMRT_HASH_SHA512, input0, output7_sha512),
#endif
};

const hc_kat_t s3hc_kat_vectors[] = {
	INIT_SHA_HC_KAT_T(CMRT_HASH_SHA256, input1, output4_sha256),
#ifdef CONFIG_SUPERVISOR_MODE
	INIT_SHA_HC_KAT_T(CMRT_HASH_SHA3_256, input1, output1_sha3_sha256),
	INIT_HMAC_HC_KAT_T(CMRT_HASH_SHA3_256, key0, input1, output2_hmac_sha3_sha256),
#endif
#if defined(CONFIG_SUPERVISOR_MODE) || defined(CONFIG_CMRT_FBOOT_HAS_ECDSA_P521)
	INIT_SHA_HC_KAT_T(CMRT_HASH_SHA512, input1, output5_sha512),
#endif
};
#endif

#ifdef CONFIG_CMRT_ASIL_B_MODE
/* Populate HC KAT vectors array. */
const hc_kat_t s2hc_kat_vectors[] = {
	INIT_SHA_HC_KAT_T(CMRT_HASH_SHA256, input0, output3_sha256),
	INIT_HMAC_HC_KAT_T(CMRT_HASH_SHA256, key0, input0, output2_hmac_sha256),
	INIT_SHA_HC_KAT_T(CMRT_HASH_SHA512, input0, output7_sha512),
	INIT_HMAC_HC_KAT_T(CMRT_HASH_SHA224, key0, input0, output0_hmac_sha224),
	INIT_SHA_HC_KAT_T(CMRT_HASH_SHA224, input0, output1_sha224),
	INIT_HMAC_HC_KAT_T(CMRT_HASH_SHA384, key0, input0, output4_hmac_sha384),
	INIT_SHA_HC_KAT_T(CMRT_HASH_SHA384, input0, output5_sha384),
	INIT_HMAC_HC_KAT_T(CMRT_HASH_SHA512, key0, input0, output6_hmac_sha512),
	INIT_SHA_HC_KAT_T(CMRT_HASH_SHA512_224, input0, output8_sha512_224),
	INIT_SHA_HC_KAT_T(CMRT_HASH_SHA512_256, input0, output9_sha512_256),
};

const hc_kat_t s3hc_kat_vectors[] = {
	INIT_SHA_HC_KAT_T(CMRT_HASH_SHA256, input1, output4_sha256),
#ifdef CONFIG_SUPERVISOR_MODE
	INIT_SHA_HC_KAT_T(CMRT_HASH_SHA3_256, input1, output1_sha3_sha256),
	INIT_HMAC_HC_KAT_T(CMRT_HASH_SHA3_256, key0, input1, output2_hmac_sha3_sha256),
#endif
#if defined(CONFIG_SUPERVISOR_MODE) || defined(CONFIG_CMRT_FBOOT_HAS_ECDSA_P521)
	INIT_SHA_HC_KAT_T(CMRT_HASH_SHA512, input1, output5_sha512),
#endif
};
#endif


const struct hc_known s2hc_known = {
	sizeof(s2hc_kat_vectors) / sizeof(s2hc_kat_vectors[0]),
	s2hc_kat_vectors
};

const struct hc_known s3hc_known = {
	sizeof(s3hc_kat_vectors) / sizeof(s3hc_kat_vectors[0]),
	s3hc_kat_vectors
};


#define MAX_OUTPUT_WORDS 16UL

static void hc_run_kat(cmrt_hc_t hc, const hc_kat_t *kat)
{
	uint32_t output[MAX_OUTPUT_WORDS];
	size_t outlen = sizeof(output);

	/* Init the core. */
	int rc = cmrt_hc_init(hc, kat->algo, kat->key, kat->keylen);
	if (rc != 0) {
		cmrt_eac_kat_error(CORE_ID_HC, -EXDEV, rc);
	}

	/* Push in data and close. */
	rc = cmrt_hc_final(hc, kat->input, kat->inlen, output, &outlen);
	if (rc != 0) {
		cmrt_eac_kat_error(CORE_ID_HC, -EXDEV, rc);
	}

	/* Verify the results. */
	if (kat->outlen != outlen) {
		cmrt_eac_kat_error(CORE_ID_HC, -EXDEV, -EFAULT);
	}
	if (memcmp((const void *)kat->output, (const void *)output, outlen) != 0) {
		cmrt_eac_kat_error(CORE_ID_HC, -EXDEV, -EFAULT);
	}

	rc = cmrt_dd_flush((cmrt_dd_context_t *)hc);
	if (rc != 0) {
		cmrt_eac_kat_error(CORE_ID_HC, -EXDEV, rc);
	}
	/* Success if we are here. */
}

void hc_open_kat(cmrt_dd_context_t *context)
{
	LOG_INF("Running HC 0x%x KAT vectors", context->dd->base);

	cmrt_hc_t hc = (cmrt_hc_t)context;
	cmrt_hc_dd_t *hcdd = (cmrt_hc_dd_t *)context->dd;
	const struct hc_known *kat = hcdd->kat;

	if (kat != NULL) {
		const hc_kat_t *const v = kat->v;
		unsigned int n = kat->n;
		for (unsigned int i = 0; i < n; ++i) {
			hc_run_kat(hc, &v[i]);
		}
	}
}

int hc_init_kat(const struct device *dev)
{
	ARG_UNUSED(dev);
#ifdef CONFIG_CMRT_FIPS_140_MODE
	/* Only run in mission and in fips mode. */
	uint32_t state = sys_read32((mm_reg_t)(CMRT_SIC_BASE+R_DEVICE_LIFECYCLE));
	uint32_t fips = sys_read32((mm_reg_t)(CMRT_SIC_BASE+R_FIPS_MODE));
	if (state != DLC_MISSION || (fips & FIPS_MODE_ENTER_FLAG) == 0) {
		return 0;
	}
#endif
#if defined(CONFIG_CMRT_FIPS_140_MODE) || (defined(CONFIG_CMRT_ASIL_B_MODE) && !defined(CONFIG_SUPERVISOR_MODE))
#ifdef CONFIG_CMRT_FBOOT
	cmrt_hc_t hc = (cmrt_hc_t)cmrt_dd_open(DEVICE_DT_GET(DT_CHOSEN(rambus_fboot_hc)), CMRT_O_HWC_FORCE_KAT, NULL);
	if (!cmrt_dd_valid(hc)) {
		cmrt_eac_kat_error(CORE_ID_HC, -EXDEV, -ENODEV);
	}
	cmrt_hc_close(hc);
#else
	cmrt_hc_t hc = cmrt_hc_open(NULL, CMRT_O_HWC_FORCE_KAT);
	if (!cmrt_dd_valid(hc)) {
		cmrt_eac_kat_error(CORE_ID_HC, -EXDEV, -ENODEV);
	}
	cmrt_hc_close(hc);
#ifdef CONFIG_CMRT_HC2
	cmrt_hc_t hc2 = cmrt_hc2_open(CMRT_O_HWC_FORCE_KAT);
	if (!cmrt_dd_valid(hc2)) {
		cmrt_eac_kat_error(CORE_ID_HC2, -EXDEV, -ENODEV);
	}
	cmrt_hc_close(hc2);
#endif
#endif
#endif
	return 0;
}
